v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {p_ibias.sym} -50 -30 0 0 {name=x1}
C {pcell1s.sym} 360 -20 0 0 {name=x2}
